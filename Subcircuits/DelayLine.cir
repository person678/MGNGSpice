C1 Delay_LineDL1 0 470n
C2 Delay_LineDL2 0 470n
C3 Delay_LineDL3 0 470n
C4 Delay_LineDL4 0 470n
C5 Delay_LineDL5 0 470n
C6 Delay_LineDL6 0 470n
C7 Delay_LineDL7 0 470n
C8 Delay_LineDL8 0 470n
C9 Delay_LineDL9 0 470n
C10 Delay_LineDL10 0 470n
C11 Delay_LineDL11 0 470n
C12 Delay_LineDL12 0 470n
C13 Delay_LineDL13 0 470n
C14 Delay_LineDL14 0 470n
C15 Delay_LineDL15 0 470n
C16 Delay_LineDL16 0 470n
C17 Delay_LineDL17 0 470n
C18 Delay_LineDL18 0 470n
C19 Delay_LineDL19 0 470n
C20 Delay_LineDL20 0 470n
C21 Delay_LineDL21 0 470n
C22 Delay_LineDL22 0 470n
C23 Delay_LineDL23 0 470n
C24 Delay_LineDL24 0 470n
C25 Delay_LineDL25 0 470n
C26 Delay_LineDL26 0 470n
C27 Delay_LineDL27 0 470n
C28 Delay_LineDL28 0 470n
C29 Delay_LineDL29 0 470n
C30 Delay_LineDL30 0 470n
L1 Net-_L1-Pad1_ Delay_LineDL1 10m
L2 Delay_LineDL1 Net-_L2-Pad2_ 10m
L3 Net-_L2-Pad2_ Delay_LineDL2 10m
L4 Delay_LineDL2 Net-_L4-Pad2_ 10m
L5 Net-_L4-Pad2_ Delay_LineDL3 10m
L6 Delay_LineDL3 Net-_L6-Pad2_ 10m
L7 Net-_L6-Pad2_ Delay_LineDL4 10m
L8 Delay_LineDL4 Net-_L8-Pad2_ 10m
L9 Net-_L8-Pad2_ Delay_LineDL5 10m
L10 Delay_LineDL5 Net-_L10-Pad2_ 10m
L11 Net-_L10-Pad2_ Delay_LineDL6 10m
L12 Delay_LineDL6 Net-_L12-Pad2_ 10m
L13 Net-_L12-Pad2_ Delay_LineDL7 10m
L14 Delay_LineDL7 Net-_L14-Pad2_ 10m
L15 Net-_L14-Pad2_ Delay_LineDL8 10m
L16 Delay_LineDL8 Net-_L16-Pad2_ 10m
L17 Net-_L16-Pad2_ Delay_LineDL9 10m
L18 Delay_LineDL9 Net-_L18-Pad2_ 10m
L19 Net-_L18-Pad2_ Delay_LineDL10 10m
L20 Delay_LineDL10 Net-_L20-Pad2_ 10m
L21 Net-_L21-Pad1_ Delay_LineDL20 10m
L22 Delay_LineDL20 Net-_L22-Pad2_ 10m
L23 Net-_L22-Pad2_ Delay_LineDL19 10m
L24 Delay_LineDL19 Net-_L24-Pad2_ 10m
L25 Net-_L24-Pad2_ Delay_LineDL18 10m
L26 Delay_LineDL18 Net-_L26-Pad2_ 10m
L27 Net-_L26-Pad2_ Delay_LineDL17 10m
L28 Delay_LineDL17 Net-_L28-Pad2_ 10m
L29 Net-_L28-Pad2_ Delay_LineDL16 10m
L30 Delay_LineDL16 Net-_L30-Pad2_ 10m
L31 Net-_L30-Pad2_ Delay_LineDL15 10m
L32 Delay_LineDL15 Net-_L32-Pad2_ 10m
L33 Net-_L32-Pad2_ Delay_LineDL14 10m
L34 Delay_LineDL14 Net-_L34-Pad2_ 10m
L35 Net-_L34-Pad2_ Delay_LineDL13 10m
L36 Delay_LineDL13 Net-_L36-Pad2_ 10m
L37 Net-_L36-Pad2_ Delay_LineDL12 10m
L38 Delay_LineDL12 Net-_L38-Pad2_ 10m
L39 Net-_L38-Pad2_ Delay_LineDL11 10m
L40 Delay_LineDL11 Net-_L20-Pad2_ 10m
L41 Net-_L21-Pad1_ Delay_LineDL21 10m
L42 Delay_LineDL21 Net-_L42-Pad2_ 10m
L43 Net-_L42-Pad2_ Delay_LineDL22 10m
L44 Delay_LineDL22 Net-_L44-Pad2_ 10m
L45 Net-_L44-Pad2_ Delay_LineDL23 10m
L46 Delay_LineDL23 Net-_L46-Pad2_ 10m
L47 Net-_L46-Pad2_ Delay_LineDL24 10m
L48 Delay_LineDL24 Net-_L48-Pad2_ 10m
L49 Net-_L48-Pad2_ Delay_LineDL25 10m
L50 Delay_LineDL25 Net-_L50-Pad2_ 10m
L51 Net-_L50-Pad2_ Delay_LineDL26 10m
L52 Delay_LineDL26 Net-_L52-Pad2_ 10m
L53 Net-_L52-Pad2_ Delay_LineDL27 10m
L54 Delay_LineDL27 Net-_L54-Pad2_ 10m
L55 Net-_L54-Pad2_ Delay_LineDL28 10m
L56 Delay_LineDL28 Net-_L56-Pad2_ 10m
L57 Net-_L56-Pad2_ Delay_LineDL29 10m
L58 Delay_LineDL29 Net-_L58-Pad2_ 10m
L59 Net-_L58-Pad2_ DelayLineDL30 10m
L60 DelayLineDL30 Net-_L60-Pad2_ 10m
RDLIn DLIn Net-_L1-Pad1_ 190
RDLOut 0 Net-_L60-Pad2_ 190
