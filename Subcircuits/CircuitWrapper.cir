.include JFETNL.cir
.include Integrator.cir
.include InputAmp.cir
.include DelayLine.cir
