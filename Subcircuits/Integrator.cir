XINA IntegratorINAPos IntegratorINANeg VDD 0 DLIn AD712_AD
CInt1 IntegratorINAPos 0 100n
RINAF2 0 IntegratorINANeg 3000
RINAF1 IntegratorINANeg DLIn 3000
R9 NLOut IntegratorINAPos 3k
