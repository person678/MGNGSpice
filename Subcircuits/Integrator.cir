XINA IntegratorINAPos IntegratorINANeg VDD VNeg DLIn AD712_AD
CINT1 IntegratorINAPos 0 100n
RINTAF2 0 IntegratorINANeg 3000
RINTAF1 IntegratorINANeg DLIn 3000
RINT9 NLOut IntegratorINAPos 3k
