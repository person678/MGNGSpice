XINA IntegratorINAPos IntegratorINANeg Delay_LineDLIn VDD 0 AD712
CInt1 IntegratorINAPos 0 100n
RINAF2 0 IntegratorINANeg 3000
RINAF1 IntegratorINANeg Delay_LineDLIn 3000
R9 NLOut IntegratorINAPos 3k
