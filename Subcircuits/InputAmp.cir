XIA Input_Amplifier_StageOA1Pos Input_Amplifier_StageOA1Neg VDD 0 IAOut AD712_AD
R1 VIn Input_Amplifier_StageOA1Pos 1k
R2 DLOut Input_Amplifier_StageOA1Pos 1k
RIAF1 Input_Amplifier_StageOA1Neg IAOut 3k
RIAF2 Input_Amplifier_StageOA1Neg GND 3k
