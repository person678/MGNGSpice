V1 VDD 0 DC 12
V2 VIn 0 DC 5
V3 VNeg 0 DC -10
XIA InputAmpPos InputAmpNeg VDD VNeg IAOut AD712_AD
RIN1 VIn InputAmpPos 1k
RIN2 DLOut InputAmpPos 1k
RIAF1 InputAmpNeg IAOut 2k
RIAF2 InputAmpNeg GND 3k
